# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89F0650 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xFFFF) CLOCK(32000000)
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ../user/: main.c
  group Driver
    ../user/: Uart.c Timer.c SPI.c RTC.c I2C_SLAVE.c I2C.c ADC.c
  group APP
    ../user/: QMA6981.c
